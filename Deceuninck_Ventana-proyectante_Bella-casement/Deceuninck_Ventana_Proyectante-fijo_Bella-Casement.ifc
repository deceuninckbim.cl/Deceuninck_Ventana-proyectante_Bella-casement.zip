Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2023-12-26T08:54:53
Author: Scarlett Alday, s.aldayaranda@gmail.com
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20200210_1400(x64) - Exporter 20.3.2.0 - Alternate UI 20.3.2.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Dec 26 08:54:53 2023 * Host: LAPTOP-VOCR0U39 * Database: C:\Users\salda\AppData\Local\Temp\792897df-17cf-4808-9be0-231cc600ccb6\47d4b383-ff7c-4a4c-95f7-123b0f8e5e23\ifc * Database version: 5507 * Database creation date: Tue Dec 26 08:54:53 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Dec 26 08:54:53 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Dec 26 08:54:53 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcBuildingElementProxy: Deceuninck_Ventana-proyectante_Bella-casement:Projecting window, Deceuninck_Ventana-proyectante_Bella-casement:Projecting window:600405
In: Level 1
Type - Classification: B2020100 Windows (Uniformat); Material: Deceuninck - 1.White/PVC, PVC, Galvanized steel, Glass
Type - Analytical Properties - Analytic Construction: <None>; Define Thermal Properties by: Schematic Type
Type - Construction - Wall Closure: By host
Type - Dimensions - Construction Height: 805 mm; Construction Width: 605 mm; Frame Fit: 27 mm; Glass Height: 618 mm; Glass Width: 487 mm; Height: 800 mm; Max. Height: 1270 mm; Max. Width: 1070 mm; Rough Height: 0 mm; Width: 600 mm
Type - Identity Data - Assembly Code: B2020100; Assembly Description: Windows; Constructive Depth: 38mm; C-Section Model: https://skfb.ly/oOGsJ; Glass type: Monolitic, laminated, thermopanel; Glazing capacity: 4 - 20mm; Internacional Certification: ISO 9001-ISO 14001-BS 0HSAS 18001 approved by TUV Rheiland; Line: Bella casement; Maintenance: https://deceuninck.cl/pdf/mantencion.pdf; Manufacturer: Deceuninck; Model: Awning; NOTE*: Consider opening limiter; OmniClass Number: 23.30.20.00; OmniClass Title: Windows; Opening: Exterior; Panels: 1 casement; Technical Area: info@deceuninckbim.cl; Type Comments: Calculations made based on load of 500 Pa (103km/h); Type Mark: 106; Type Name: Projecting window; URL: www.deceuninck.cl; Use: Interior
Type - Materials and Finishes - Available colours: https://deceuninckbim.cl/pdf/fichas/Bella-casement-proyectante.pdf; Frame: Deceuninck - 1.White/PVC; Handle: PVC; Reinforcement: Galvanized steel; Sash: Deceuninck - 1.White/PVC
Type - Model Properties - Acoustic insulation: Rw=29 (-1;-2) dB according to ISO 140-3, ISO 717 **; Air permeability: Class 3 according to EN 12207; Fire retardant: Class C-s3, d2 according to EN 13501-1; Water tightness: Class 6A according to EN 12208; Wind load resistance: Class C3/B4 according to EN 12210
Type - Other - Category: Windows; Altura de antepecho por defecto: 800 mm; Family Name: Deceuninck_Ventana-proyectante_Bella-casement
Type - Structural - Includes reinforcement: yes
Type - Pset_ManufacturerTypeInformation - Manufacturer: Deceuninck
Type - Pset_ProductRequirements - Category: Windows
Type - Pset_ProvisionForVoid - Width: 600 mm; Height: 800 mm
Material: Glass, Deceuninck - 1.White/PVC
Pset_BuildingElementProxyCommon - Reference: Projecting window; sets with these values: 2
Constraints - Level: Level: Level 1; Sill Height: 800 mm
Dimensions - Area: 1.17451 m2; Volume: 0.00892921 m3
Identity Data - Mark: 95
Other - Family: Deceuninck_Ventana-proyectante_Bella-casement: Projecting window; Family and Type: Deceuninck_Ventana-proyectante_Bella-casement: Projecting window; Head Height: 1600 mm; Host Id: Basic Wall: Generic - 200mm; ON_OFF - Height: no; ON_OFF - Width: no; Type: Deceuninck_Ventana-proyectante_Bella-casement: Projecting window; Type Id: Deceuninck_Ventana-proyectante_Bella-casement: Projecting window
Phasing - Phase Created: New Construction
